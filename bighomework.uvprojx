# Keil uVision project bighomework.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC1114FBD48/302 NXP
  pack: Keil.LPC1100_DFP.1.4.0
  cpu: IRAM(0x10000000,0x2000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: s1 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group Source Group 1
    ./: main.c main.h uart_api.c uart_api.h gpio_api.c gpio_api.h adc_api.c adc_api.h LPC11xx.h power_profiles.h startup_LPC11xx.s system_LPC11xx.c system_LPC11xx.h
software components: CMSIS:CORE 5.0.1
